# Keil uVision project OLED.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: OLED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SRC
  group Source Group 1
    ./: STARTUP.A51 main.c Delay.c Delay.h baojing.c baojing.h
    ./SRC/: oled.c
